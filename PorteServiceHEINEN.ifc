Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: ee467105-6f57-48d6-a45c-2bb3b6798d8a.ifc
Time: 2022-10-13T11:27:30
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcDoor
In: Bouwlaag
Material: staal
Pset_Data - WUID: AgAAAF2ZFbsfAAAA2XACAAUaywAAfA0CAHQGAADacAIAqYUCAAUAkg4BAQAAAAEAAABFAAEBAAAAAgAAABYHAQEAAAAKAAAAmAUBAQAAABwAAABoCAEBAAAAHQAAANRPAAAFSLwAAHA-AABFkQAAEr0AANx7AgAAAK1wAgAFDvUAABkQAQC7cwAArnICAKKFAgAFAGoLAQEAAAADAAAAPgABAQAAAAUAAACUAgIDAAAAAAAwoUBMAgEBAAAABgAAACwCAgMAAAAAACCMQOB3AgAC33cCAOF3AgABADAIAQEAAAAEAAAAwGsCAAOORAIAj0QCAJBEAgAAANRPAAAFSLwAAHA-AABFkQAAEr0AANx7AgAAAOmTAgAFDoYAABkQAQC7cwAAsnICAOqTAgACAGoLAQEAAAAHAAAATAIBAQAAAAkAAADgdwIAAt93AgDhdwIAAQAwCAEBAAAACAAAAMBrAgADjkQCAI9EAgCQRAIAAADygQAABWa5AABkMAAAxqcAAKOtAADp2AAAAAAllAIABfwyAADaGQEAu3MAALJyAgAXlAIABgDdBQEBAAAACwAAAIsCAQEAAAANAAAAPgMBAQAAAA8AAADGBQEBAAAAEQAAADQNAQEAAAAaAAAAtAUBAQAAABsAAADocgIABbtrAAD_LQAAu3MAALJyAgDqcgIAAQAQAAEBAAAADAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAN9yAgAFJFoAAKooAAC7cwAAsnICAOFyAgABABAAAQEAAAAOAAAA764AAAVwuQAAZDAAAManAACjrQAA6dgAAAAA5HICAAU1lwAA_y0AALtzAACycgIABYcCAAEAEAABAQAAABAAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAACxcgIABSooAACAgQIAu3MAALJyAgDbfwIABADUAQEBAAAAEgAAAKIGAQEAAAAUAAAAvwYBAQAAABYAAABuAAEBAAAAGAAAAMhyAgAFKigAAO-2AAC7cwAAsnICANp_AgABABAAAQEAAAATAAAAQmoAAAVg3wAAZDAAAManAACjrQAA6dgAAAAAznICAAXRowAAahwAALtzAACycgIAzHICAAEAEAABAQAAABUAAACgqAAABYVAAABkMAAAxqcAAKOtAADp2AAAAADOcgIABdGjAABqHAAAu3MAALJyAgDMcgIAAQAQAAEBAAAAFwAAAKCoAAAFhUAAAGQwAADGpwAAo60AAOnYAAAAAMhyAgAFKigAAO-2AAC7cwAAsnICANp_AgABABAAAQEAAAAZAAAAQmoAAAVg3wAAZDAAAManAACjrQAA6dgAAAAA1E8AAAVIvAAAcD4AAEWRAAASvQAA3HsCAAAA1E8AAAVIvAAAcD4AAEWRAAASvQAA3HsCAAAA1E8AAAVIvAAAcD4AAEWRAAASvQAA3HsCAAAArHICAAXnkwIA9jMAALtzAACucgIArXICAAEAEAABAQAAAB4AAADygQAABWa5AABkMAAAxqcAAKOtAADp2AAAAAA); Hyperlink: https://bcb-online.nl/s/009d52c5316b347e2b7055ff7d0e48144; U-waarde: 1,9 w/m²·k; hoogte onder: 4 mm; dagmaatbreedte: 870 mm; type: basisdeur; merk: Heinen; stelruimte: 5 mm; inbouwhoogte: 2278 mm; breedte: 1010 mm; hoogte: 2278 mm; max. gebruiks frequentie: 1000000 aantal per etmaal; STABU2: 30.32.12; zijbelemmering voor koeling: False; dagmaathoogte: 2188 mm; belemmering rel. hoogte: 0,36; dikte: 122 mm; overstek rel. hoogte: 1; geschikt voor buitentoepassing: True; serie: Metal Plus; theoretische levensduur: 100; doorgangshoogte: 2188 mm; kenmerkende grondstof: staal; Rw: 30 db(a); stelruimte boven: 4 mm; inbraakwerendheidsklasse: 2; inbouwbreedte: 1010 mm; belemmering rel. breedte: 3,73; doorgangsbreedte: 800 mm; bevindt zich buiten: True; luchtdoorlatendheid klasse: 1; toebehoren: geen; kozijn: deurkozijn (zonder deur) deurkozijn Heinen - Metal Plus standaard staal; dorpel: geen; hang en sluitwerk: hang- en sluitwerk set enkele deur Heinen basisdeur (vluchtweg EN179/1125); deur: losse deur vlakke plaat Heinen - Metal Plus basisdeur
